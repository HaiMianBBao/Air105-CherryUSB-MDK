# Keil uVision project air105_mdk_cherryusb.uvprojx, settings and files
target air105_mdk_cherryusb (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: air105_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Device\Air105\Include;..\Drivers\CMSIS\Include;..\Drivers\Air105_StdPeriph_Driver\inc;..\Hardwares\inc;..\User;..\RTT;..\CherryUSB\class\hid;..\CherryUSB\class\cdc;..\CherryUSB\common;..\CherryUSB\core;..\..\air105_cherryusb_mdk;..\CherryUSB\class\msc;..\CherryUSB\demo;..\CherryUSB\port\musb
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0xffffff
  memory RVCT9: RAM 0x20000000 size 0x80000
  group STARTUP
    ../Drivers/CMSIS/Device/Air105/Source/ARM/: startup_air105.s
  group CMSIS
    ../Drivers/CMSIS/Device/Air105/Source/: system_air105.c
  group StdPeriphLib
    ../Drivers/Air105_StdPeriph_Driver/src/: air105_adc.c air105_cache.c air105_crc.c air105_dac.c air105_dcmi.c air105_dma.c air105_exti.c air105_gpio.c air105_hspim.c air105_i2c.c air105_kcu.c air105_lcdi.c air105_otp.c air105_qspi.c air105_rtc.c air105_spi.c air105_sysctrl.c air105_timer.c air105_trng.c air105_uart.c air105_wdt.c misc.c air105_usb_std.c
  group Hardware
    ../Hardwares/src/: delay.c sysc.c usart.c
  group User
    ../User/: air105_it.c main.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group CherryUSB
    ../CherryUSB/class/cdc/: usbd_cdc.c
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/demo/: cdc_acm_template.c hid_keyboard_template.c msc_ram_template.c cdc_acm_msc_template.c hid_mouse_template.c cdc_acm_hid_msc_template.c
    ../CherryUSB/class/msc/: usbd_msc.c
    ../: cherryusb_demo.c usb_dc_musb.c
